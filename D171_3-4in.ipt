# Autodesk Inventor part: D171_3-4in
## iProperties
Created: 2011-02
Part Number: D171_3-4in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
